# Keil uVision project 秒表.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 秒表 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h main_time.c Timer0.c Timer0.h NixieTube.c NixieTube.h key.c key.h
