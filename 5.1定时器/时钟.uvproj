# Keil uVision project 时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: clock.c Delay.c Delay.h LCD1602.c LCD1602.h Timer0.h Timer0.c
