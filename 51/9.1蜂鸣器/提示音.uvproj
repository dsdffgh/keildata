# Keil uVision project 提示音.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 提示音 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: beep_main.c Delay.c Delay.h key.c key.h NixieTube.c NixieTube.h Buzzer.c Buzzer.h
