# Keil uVision project 矩阵键盘.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 矩阵键盘 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./user/: main.c
    ./public/: Delay.c Delay.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h
