#include <REGX52.H>
#include "MatrixLED.h"
#define Lenth (32-5)*8-6-16
unsigned char code animation[Lenth] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0xFF,0xC0,0x80,0xC0,0xFF,
    0xFF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x3E,0x7F,0xEB,0xC9,0x88,0xC8,0xE9,0x79,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0xE0,0xFC,0x3F,0x07,0x3F,0xFC,0xFC,0x7F,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0xE0,0xFC,0x3F,0x07,0x0F,0x3E,0xF8,0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x3E,0x7F,0xEB,0xC9,0x88,0xC8,0xE9,0x79,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xCF,0xDF,0xD8,0x99,0xD9,0xFF,
    0x7F,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0xFF,0xFF,0xC0,0x80,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0xf9,0xf9,0x00,0x00,
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    };
void main()
{
    unsigned char i, Offset = 0, Count;
    Matrix_LEDInit(); // 初始化
    while (1)
    {
        for (i = 0; i < 8; i++)
        {
            MatrixLED_ShowColumn(i, *(animation + i + Offset));
        }

        Count++;
        if (Count > 10)//一帧扫描10遍，相当于延时，也可以使用定时器，每隔一段时间offset+1
        {
            Count = 0;
            Offset++;
            if (Offset > Lenth - 8)
            {
                Offset = 0;
            }
        }
    }
}