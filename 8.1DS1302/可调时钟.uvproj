# Keil uVision project 可调时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 可调时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AdjustableClock.c Delay.c Delay.h DS1302.c DS1302.h key.c key.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h Timer0.c Timer0.h
